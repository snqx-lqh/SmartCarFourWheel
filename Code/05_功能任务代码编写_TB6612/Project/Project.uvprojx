# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .;.\..\CMSIS\Core;.\..\CMSIS\STM32F10x;.\..\Lib\inc;.\..\USER\BSP;.\..\USER\APP;..\FreeRTOS\include;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM3;..\FreeRTOS;..\USER\TASK
  asm define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Main
    ./../CMSIS/STM32F10x/: stm32f10x_it.c system_stm32f10x.c
    ./: main.c
  group Lib
    ./../Lib/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
  group CMSIS
    ./../CMSIS/Core/: core_cm3.c
    ./../CMSIS/Startup/: startup_stm32f10x_hd.s
  group Bsp
    ./../USER/BSP/: bsp_led.c bsp_key.c bsp_delay.c bsp_sys.c bsp_exti.c bsp_timer.c bsp_usart.c bsp_adc.c
    ../USER/BSP/: bsp_motor.c
  group App
    ../USER/APP/: control.c filter.c keyscan.c mpu6050.c oled.c bluetooth_debugger.c pid.c
  group Task
    ../USER/TASK/: start_task.c user_task.c bluetooth_task.c chassis_task.c nrf_task.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/include/: FreeRTOSConfig.h
